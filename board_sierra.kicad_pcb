# Repository visionspacetec/VST104-Sierra

File README.md:

# VST104 Board Sierra - single MCU OBC for PC104
This repository contains the KiCad project and other documents created during the development of Board Sierra under [VST104 project](https://github.com/visionspacetec/VST104/). This PC104 CubeSats module is a single redundant onboard computer designed to fulfill most space industry requirements.

<p align="center">
  <br>

  <br><br>
  <b>Fig 1.</b> Board Sierra OBC module 3D visualisation top (left) and bottom (right) side.
  <br><br>
</p>

## Basic specifications
* **`processor:`** This onboard computer is driven by state of the art, ultra-low-power **STM32L496 ARM® Cortex®-M4 core** microcontroller. This MCU is capable of running **up to 78[MHz]** in our design.
* **`clock:`** Microcontroller is driven by two external clock sources. Low-speed **external 32.768[kHz] oscillator** (LSE) and high-speed **external 26[MHz] oscillator** (HSE). The MCU is capable of temporarily disable the HSE to achieve better power consumption.
* **`memory:`** Two groups of triple redundant external memories are available for data storage and processing. The triple redundancy was chosen as an effective measure against single event effects. The first memory group is **256 [Mbit] Flash** wired via Quad-SPI interface and the second one is **2 [Mbit] F-RAM** using SPI.
* **`peripherals:`** This module can communicate with other CubeSat subsystems using a wide variety of redundant protocols. The main PC104 header is capable of connecting to **2x CAN-BUS, 3x I2C, 4x UART** (with CTS and RTS), **2xSPI** (2 enables each), and **22 general purpose** A/D I/O pins. All of the listed peripherals are wired thru separated isolators controlled by the MCU. On top of that, separate traces are used for system check and maintenance signals, such as: WatchDog, KillSwitch, CPUmode, Sync, FaultCollector. The pinout of these interferences is shown in figure 3.
* **`connectivity:`** A user can program and debug this OBC using **SWI and/or UART interface**. These interfaces are accessible on the board's edge on a separate connector with integrated electrostatic discharge protection circuitry. The SWI interface is compatible with STM ST-LINK series programmers (including SWO pin).

<p align="center">
  <br>
  
  <br><br>
  <b>Fig 2.</b> Important circuitry groups on top (left) and bottom (right) side of the module.
  <br><br>
</p>

## Features
* All used components are suitable for the space environment, following: mechanical failure qualifications **AEC-Q100 or AEC-Q200** and **military rated** operational temperatures (-40°C to +125°C).
* This module requires two separate power lines of 3.3[V] and 5[V] ratings. A **robust power management** circuitry is present separately on these lines, providing various functionalities. Namely: tunable over and under-voltage protection, tunable over-current protection, amplified current monitoring output, kill switching, or simultaneous power down.
* A group of **seven I2C temperature sensors** is spread over the entire module. These sensors are used to check the temperature of essential submodules such as: 2x power management, 2x CAN-BUS drivers, 2x external memories, and 1x STM32 microcontroller. Also, the MCU can power these sensors in case of power saving or latch-up events.
* A compact design was one of our priorities during the development of this module. As a result, this module's full three-fourths are left empty and ready to **accommodate any required payload**. This current version is the payload sector represented as a universal soldering array with exposed power lines (outside the power management).

<p align="center">
  <br>
  
  <br><br>
  <b>Fig 3.</b> PC104 header pinout supported by this OBC module.
  <br><br>
</p>

## Debug & Program connector
A separate 2x4 female format connector on the board's left side is used for debugging and programming.  SWI and UART5 interfaces of the boarded STM32 microprocessor are wired to this connector, as shown in figure 4. This interface is fully compatible with STM ST-Link family programmers. 

<p align="center">
  <br>
  
  <br><br>
  <b>Fig 4.</b> Pinout of the debug and program connector.
  <br><br>
</p>

## References
The design of this PC 104 SBC module was processed under evaluation of the following documents:

[1] : [STM32L496xx datasheet](https://www.st.com/resource/en/datasheet/stm32l496ae.pdf)  
[2] : [STM32L496xx getting started manual](https://www.st.com/resource/en/application_note/dm00125306-getting-started-with-stm32l4-series-and-stm32l4-series-hardware-development-stmicroelectronics.pdf)  
[3] : [STM32 oscillator design guide](https://www.st.com/resource/en/application_note/cd00221665-oscillator-design-guide-for-stm8afals-stm32-mcus-and-mpus-stmicroelectronics.pdf)  
[4] : [STM32 Quad-SPI interface](https://www.st.com/resource/en/application_note/dm00227538-quadspi-interface-on-stm32-microcontrollers-and-microprocessors-stmicroelectronics.pdf)  
[5] : [Common mode chokes in CAN networks](https://www.ti.com/lit/an/slla271/slla271.pdf?ts=1593763769749&ref_url=https%253A%252F%252Fwww.google.com%252F#:~:text=In%20general%2C%20common%2Dmode%20chokes,results%20in%20the%20CAN%20network.&text=Following%20the%20choke%20in%20the,is%20the%20optional%20termination%20circuit.)  
[6] : [Isolated CAN systems with protection](https://www.ti.com/lit/an/slla419/slla419.pdf?ts=1593773861416&ref_url=https%253A%252F%252Fwww.google.com%252F#:~:text=A%20bidirectional%20TVS%20diode%20can,ratings%20up%20to%20several%20kilowatts.)

## KiCad design board_sierra.kicad_pcb

Parts:
AS1, AS2, AS3, AS4, AS5, AS6, AS7, AS8, AS9, AS10, AS11, AS12, AS13, AS14, AS15: DGQ2788A; mini_QFN-16-1.8x2.6mm
C1, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C16, C18, C20, C27, C32, C33, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C55, C58, C59, C60, C61, C62, C63: 100n; C_SMD_0402
C2, C17, C70, C71: 1u; C_SMD_0603
C3, C4, C22, C23, C24, C25, C29, C30, C31, C34, C35, C47, C48, C53, C54: 10n; C_SMD_0402
C15, C26: 10u; C_SMD_0805
C19, C21: 4u7; C_SMD_0603
C28, C66, C67: 1n; C_SMD_0402
C49, C50: 17p; C_SMD_0402
C51: 22n; C_SMD_0402
C52: 15n; C_SMD_0402
C56, C57: 100u; C_SMD_1210
C64, C65: 4n7; C_SMD_0402
C68, C69, C72, C73: 100p; C_SMD_0402
D1, D2, D3: Schottky diode; D_SMD_0402
EF1, EF2: TPS25940-Q1; WQFN-20_4.0x3.0mm_EPV
ESD1: SP3012-06; uDFN-14_3.5x1.35mm
F1, F2: 0; R_SMD_1206
FB1, FB2: 120@100M; R_SMD_0402
H1, H2: Conn_02x26_Odd_Even; ESQ-126-39-x-D
JC1: SW&UART; CLP-104-02-x-D
L1: 10u; L_SMD_0603
LG1: 74LVC1G11-Q100; SOT-363_TSSOP-6_2.0x1.25mm
M1, M2, M3: S25FL256L; WSON-8_6.0x8.0mm_EP
M4, M5, M6: CY15B102Q; SOIC-8_208_5.23x5.23mm
MH1, MH2, MH3, MH4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
Q1: TPS22965-Q1; WSON-8_2.0x2.0mm_EPV
Q2, Q3: TPS22965W-Q1; WSON-8_2.0x2.0mm_EPV
R1, R2, R3, R4, R10, R11, R14, R15, R16, R17, R18, R19, R20, R21, R22, R25, R26, R33, R34, R35, R36, R48, R49: 100k; R_SMD_0402
R5, R23, R24, R27, R28, R29, R30, R31, R32, R53, R67, R68, R73, R74, R76: 10k; R_SMD_0402
R6, R7, R8, R9, R12, R13, R41, R42, R43, R44, R45, R46, R69, R70, R71, R72: 22; R_SMD_0402
R37, R38, R39, R40: 4k7; R_SMD_0402
R47, R50, R54: 280k; R_SMD_0402
R51: 22k6; R_SMD_0402
R52: 115k; R_SMD_0402
R55: 8k66; R_SMD_0402
R56: 63k4; R_SMD_0402
R57: 1k; R_SMD_0402
R58: 100 0.25W; R_SMD_0603
R59, R60: 75k; R_SMD_0402
R61, R62: 33k2; R_SMD_0402
R63, R65: 110k; R_SMD_0402
R64: 60k4; R_SMD_0402
R66: 31k6; R_SMD_0402
R77, R78, R79, R80: 60.4; R_SMD_0402
RH1: ResinHole; MountingHole_1.2mm
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP19, TP20: test_point; scope_PAD_1mm
TP17, TP18: GND; scope_GND
TRC1, TRC2, TRC3: trace_0.173mm; trace_arc_0.173mm
TRC4, TRC5, TRC6, TRC7, TRC8, TRC9: trace_0.2mm; trace_arc_0.2mm
TS1, TS2, TS3, TS4, TS5, TS6, TS7: MCP9804; DFN-8_3.0x2.0mm_EP
U1: STM32L496ZGTx; LQFP-144_20x20mm_P0.5mm
U2, U3: TCAN1051-Q1; VSON-8_3.0x3.0mm_EPV
UA1, UA2, UA3, UA4: PC104_SO-24_universal
UA5: Conn_01x03; PC104_universal_OBC&FPGA
Y1: ABS07AIG; LSE_3.2x1.5mm
Y2: SiT8924; HSE_2.0x1.6mm

Connections:
+3.3VADC: C1.2, C2.2, FB1.2, U1.32 (VREF+), U1.33 (VDDA)
+3V3: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C26.2, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C55.2, C58.2, C59.2, C70.2, D1.2 (A), FB2.2, L1.1, M1.8 (VCC), M2.8 (VCC), M3.8 (VCC), M4.8 (VDD), M5.8 (VDD), M6.8 (VDD), Q1.1 (IN), Q1.2 (IN), Q2.7 (OUT), Q2.8 (OUT), R23.1, R24.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, TP19.1, U1.6 (VBAT), U1.17 (VDD), U1.39 (VDD), U1.52 (VDD), U1.62 (VDD), U1.72 (VDD), U1.84 (VDD), U1.95 (VDDIO2), U1.106 (VDDUSB), U1.108 (VDD), U1.121 (VDD), U1.131 (VDDIO2), U1.144 (VDD), U2.5 (VIO), U3.5 (VIO), Y2.4 (VDD)
+5V: AS1.10 (VCC), AS2.10 (VCC), AS3.10 (VCC), AS4.10 (VCC), AS5.10 (VCC), AS6.10 (VCC), AS7.10 (VCC), AS8.10 (VCC), AS9.10 (VCC), AS10.10 (VCC), AS11.10 (VCC), AS12.10 (VCC), AS13.10 (VCC), AS14.10 (VCC), AS15.10 (VCC), C3.2, C4.2, C22.2, C23.2, C24.2, C25.2, C29.2, C30.2, C31.2, C34.2, C35.2, C47.2, C48.2, C53.2, C54.2, C62.2, C63.2, C71.2, Q3.7 (OUT), Q3.8 (OUT), TP20.1, U2.3 (VDD), U3.3 (VDD)
/CAN1_EN: AS8.14 (EN12), R20.2, U1.86 (PD15)
/CAN1_N: AS8.12 (COM1), C72.2, R79.1, TRC4.1, TRC6.1, TRC8.1, U2.6 (CANL)
/CAN1_P: AS8.16 (COM2), C68.2, R77.1, U2.7 (CANH)
/CAN1_RX: R69.2, TP13.1, U1.139 (PB8)
/CAN1_TX: R70.2, TP14.1, U1.140 (PB9)
/CAN2_EN: AS9.14 (EN12), R21.1, U1.82 (PD13)
/CAN2_N: AS9.12 (COM1), C73.2, R80.1, U3.6 (CANL)
/CAN2_P: AS9.16 (COM2), C69.2, R78.1, TRC5.1, TRC7.1, TRC9.1, U3.7 (CANH)
/CAN2_RX: R71.2, TP15.1, U1.135 (PB5)
/CAN2_TX: R72.2, TP16.1, U1.136 (PB6)
/CL: M4.6 (CLK), M5.6 (CLK), M6.6 (CLK), R12.1, TP8.1
/CLK: M1.6 (SCK), M2.6 (SCK), M3.6 (SCK), R7.2, TP3.1
/CPU_EN: AS7.14 (EN12), R19.1, U1.64 (PE11)
/EF1_CUR: EF1.19 (IMON), R61.2, U1.29 (PC3)
/EF1_en: EF1.2 (PGOOD), LG1.6 (C), R67.2
/EF1_out: C56.1, D2.2 (A), EF1.4 (OUT), EF1.5 (OUT), EF1.6 (OUT), EF1.7 (OUT), EF1.8 (OUT), LG1.5 (VCC), Q2.1 (IN), Q2.2 (IN), R63.1, R67.1
/EF2_CUR: EF2.19 (IMON), R62.2, U1.28 (PC2)
/EF2_en: EF2.2 (PGOOD), LG1.1 (A), R68.2
/EF2_out: C57.1, D3.2 (A), EF2.4 (OUT), EF2.5 (OUT), EF2.6 (OUT), EF2.7 (OUT), EF2.8 (OUT), Q3.1 (IN), Q3.2 (IN), R65.1, R68.1
/FAULT: AS7.8 (COM4), R8.2
/GLO_EN: AS7.6 (EN34), R16.1, U1.68 (PE15)
/HD: M4.7 (~HOLD), M5.7 (~HOLD), M6.7 (~HOLD), TP12.1, U1.26 (PC0)
/I2C2_EN: Q1.3 (EN), R22.1, U1.123 (PD7)
/I2C2_SCL: R23.2, TP1.1, TS1.2 (SCL), TS2.2 (SCL), TS3.2 (SCL), TS4.2 (SCL), TS5.2 (SCL), TS6.2 (SCL), TS7.2 (SCL), U1.11 (PF1)
/I2C2_SDA: R24.2, TP2.1, TS1.1 (SDA), TS2.1 (SDA), TS3.1 (SDA), TS4.1 (SDA), TS5.1 (SDA), TS6.1 (SDA), TS7.1 (SDA), U1.10 (PF0)
/I2C3_EN: AS8.6 (EN34), R17.1, U1.85 (PD14)
/I2C3_SCL: AS8.4 (COM3), R38.2, U1.92 (PG7)
/I2C3_SDA: AS8.8 (COM4), R37.2, U1.93 (PG8)
/I2C4_EN: AS9.6 (EN34), R18.1, U1.73 (PB12)
/I2C4_SCL: AS9.4 (COM3), R40.2, U1.69 (PB10)
/I2C4_SDA: AS9.8 (COM4), R39.2, U1.70 (PB11)
/MODE: AS7.12 (COM1), R9.2
/NRST: R41.2, U1.25 (NRST)
/OSC32_IN: C49.1, U1.8 (PC14), Y1.1
/OSC32_OUT: R47.2, U1.9 (PC15)
/OSC_EN: R57.1, U1.24 (PH1)
/OSC_IN: U1.23 (PH0), Y2.3 (OUT)
/Q0: M1.5 (Q0/SI), M2.5 (Q0/SI), M3.5 (Q0/SI), TP4.1, U1.20 (PF8)
/Q1: M1.2 (Q1/SO), M2.2 (Q1/SO), M3.2 (Q1/SO), TP5.1, U1.21 (PF9)
/Q2: M1.3 (Q2/WP), M2.3 (Q2/WP), M3.3 (Q2/WP), TP6.1, U1.19 (PF7)
/Q3: M1.7 (Q3/RST), M2.7 (Q3/RST), M3.7 (Q3/RST), TP7.1, U1.18 (PF6)
/QSPI_CS1: M1.1 (CS), R27.2, U1.34 (PA0)
/QSPI_CS2: M2.1 (CS), R28.2, U1.35 (PA1)
/QSPI_CS3: M3.1 (CS), R29.2, U1.36 (PA2)
/SI: M4.5 (SI), M5.5 (SI), M6.5 (SI), R35.2, TP9.1, U1.43 (PA7)
/SO: M4.2 (SO), M5.2 (SO), M6.2 (SO), R36.2, TP10.1, U1.42 (PA6)
/SPI1_CS1: M4.1 (~CS), R30.2, U1.44 (PC4)
/SPI1_CS2: M5.1 (~CS), R31.2, U1.40 (PA4)
/SPI1_CS3: M6.1 (~CS), R32.2, U1.37 (PA3)
/SPI1_~WP: M4.3 (~WP), M5.3 (~WP), M6.3 (~WP), TP11.1, U1.27 (PC1)
/SPI2_CS1: AS11.4 (COM3), U1.96 (PC6)
/SPI2_CS2: AS2.16 (COM2), U1.60 (PE9)
/SPI2_EN: AS11.6 (EN34), AS11.14 (EN12), R26.1, U1.91 (PG6)
/SPI2_MISO: AS11.12 (COM1), U1.75 (PB14)
/SPI2_MOSI: AS11.8 (COM4), U1.76 (PB15)
/SPI2_SCK: AS11.16 (COM2), R13.1
/SPI3_CS1: AS10.4 (COM3), U1.97 (PC7)
/SPI3_CS2: AS1.16 (COM2), U1.54 (PF14)
/SPI3_EN: AS10.6 (EN34), AS10.14 (EN12), R25.1, U1.90 (PG5)
/SPI3_MISO: AS10.12 (COM1), U1.125 (PG10)
/SPI3_MOSI: AS10.8 (COM4), U1.126 (PG11)
/SPI3_SCK: AS10.16 (COM2), R6.2
/SW_CLK: R42.2, U1.109 (PA14)
/SW_DIO: R43.2, U1.105 (PA13)
/SW_O: R44.2, U1.133 (PB3)
/SYNC: AS7.4 (COM3), U1.67 (PE14)
/TEMP_VDD: C32.1, C33.1, C36.1, C37.2, C38.1, C45.1, C46.1, Q1.7 (OUT), Q1.8 (OUT), TS1.8 (VDD), TS2.5 (A2), TS2.8 (VDD), TS3.7 (A0), TS3.8 (VDD), TS4.5 (A2), TS4.6 (A1), TS4.8 (VDD), TS5.6 (A1), TS5.8 (VDD), TS6.6 (A1), TS6.7 (A0), TS6.8 (VDD), TS7.5 (A2), TS7.6 (A1), TS7.7 (A0), TS7.8 (VDD)
/UART1_CTS: AS14.8 (COM4), U1.103 (PA11)
/UART1_EN: AS14.6 (EN34), AS14.14 (EN12), R48.1, U1.89 (PG4)
/UART1_RST: AS14.12 (COM1), U1.104 (PA12)
/UART1_RX: AS14.16 (COM2), U1.102 (PA10)
/UART1_TX: AS14.4 (COM3), U1.101 (PA9)
/UART2_CTS: AS12.8 (COM4), U1.117 (PD3)
/UART2_EN: AS12.6 (EN34), AS12.14 (EN12), R33.1, U1.87 (PG2)
/UART2_RST: AS12.12 (COM1), U1.118 (PD4)
/UART2_RX: AS12.16 (COM2), U1.122 (PD6)
/UART2_TX: AS12.4 (COM3), U1.119 (PD5)
/UART3_CTS: AS13.8 (COM4), U1.80 (PD11)
/UART3_EN: AS13.6 (EN34), AS13.14 (EN12), R34.1, U1.79 (PD10)
/UART3_RST: AS13.12 (COM1), U1.81 (PD12)
/UART3_RX: AS13.4 (COM3), U1.78 (PD9)
/UART3_TX: AS13.16 (COM2), U1.77 (PD8)
/UART4_CTS: AS15.8 (COM4), U1.137 (PB7)
/UART4_EN: AS15.6 (EN34), AS15.14 (EN12), R49.1, U1.88 (PG3)
/UART4_RST: AS15.12 (COM1), U1.110 (PA15)
/UART4_RX: AS15.16 (COM2), U1.112 (PC11)
/UART4_TX: AS15.4 (COM3), U1.111 (PC10)
/UART5_RX: R46.2, U1.116 (PD2)
/UART5_TX: R45.2, U1.113 (PC12)
/USER1_1: AS1.4 (COM3), U1.53 (PF13)
/USER1_2: AS1.8 (COM4), U1.55 (PF15)
/USER1_4: AS1.12 (COM1), U1.56 (PG0)
/USER1_EN: AS1.6 (EN34), R1.2, U1.99 (PC9)
/USER2_1: AS2.4 (COM3), U1.58 (PE7)
/USER2_2: AS2.8 (COM4), U1.57 (PG1)
/USER2_4: AS2.12 (COM1), U1.59 (PE8)
/USER2_EN: AS2.6 (EN34), R2.1, U1.114 (PD0)
/USER3_1: AS3.16 (COM2), U1.50 (PF12)
/USER3_2: AS3.4 (COM3), U1.47 (PB1)
/USER3_3: AS3.12 (COM1), U1.49 (PF11)
/USER3_4: AS3.8 (COM4), U1.48 (PB2)
/USER3_EN: AS3.6 (EN34), AS3.14 (EN12), R10.1, U1.132 (PG15)
/USER4_1: AS4.4 (COM3), U1.13 (PF3)
/USER4_2: AS4.12 (COM1), U1.12 (PF2)
/USER4_3: AS4.8 (COM4), U1.5 (PE6)
/USER4_4: AS4.16 (COM2), U1.45 (PC5)
/USER4_EN: AS4.6 (EN34), AS4.14 (EN12), R11.1, U1.127 (PG12)
/USER5_1: AS5.16 (COM2), U1.3 (PE4)
/USER5_2: AS5.8 (COM4), U1.14 (PF4)
/USER5_3: AS5.4 (COM3), U1.2 (PE3)
/USER5_4: AS5.12 (COM1), U1.15 (PF5)
/USER5_EN: AS5.6 (EN34), AS5.14 (EN12), R14.1, U1.115 (PD1)
/USER6_1: AS6.16 (COM2), U1.1 (PE2)
/USER6_2: AS6.4 (COM3), U1.141 (PE0)
/USER6_3: AS6.12 (COM1), U1.4 (PE5)
/USER6_4: AS6.8 (COM4), U1.142 (PE1)
/USER6_EN: AS6.6 (EN34), AS6.14 (EN12), R15.1, U1.134 (PB4)
/USER_SPI2_EN: AS2.14 (EN12), R4.1, U1.100 (PA8)
/USER_SPI3_EN: AS1.14 (EN12), R3.2, U1.98 (PC8)
/WATCHDOG: AS7.16 (COM2), U1.66 (PE13)
CAN_1_N: AS8.11 (NO1), H1.24
CAN_1_P: AS8.15 (NO2), H1.23, TRC1.1, TRC2.1, TRC3.1
CAN_2_N: AS9.11 (NO1), H2.24
CAN_2_P: AS9.15 (NO2), H2.23
CPU_MODE: AS7.11 (NO1), H1.30
CPU_WD_1: AS7.15 (NO2), H1.27
GLO_FAULT: AS7.7 (NO4), H1.26
GLO_KS_1: H1.35, LG1.3 (B), R53.1
GLO_SYNC: AS7.3 (NO3), H1.25
GND: AS1.2 (GND), AS2.2 (GND), AS3.2 (GND), AS4.2 (GND), AS5.2 (GND), AS6.2 (GND), AS7.2 (GND), AS8.2 (GND), AS9.2 (GND), AS10.2 (GND), AS11.2 (GND), AS12.2 (GND), AS13.2 (GND), AS14.2 (GND), AS15.2 (GND), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.2, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.2, C28.2, C29.1, C30.1, C31.1, C32.2, C33.2, C34.1, C35.1, C36.2, C37.1, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.1, C48.1, C49.2, C50.1, C51.2, C52.2, C53.1, C54.1, C55.1, C56.2, C57.2, C58.1, C59.1, C60.2, C61.2, C62.1, C63.1, C64.1, C65.1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
I2C_1_SCL: AS8.3 (NO3), H1.21
I2C_1_SDA: AS8.7 (NO4), H1.22
I2C_2_SCL: AS9.3 (NO3), H2.21
I2C_2_SDA: AS9.7 (NO4), H2.22
unnamed: C27.1, D1.1 (K), Q1.4 (BIAS)
unnamed: C28.1, Q1.6 (CT)
unnamed: C50.2, R47.1, Y1.2
unnamed: C51.1, EF1.18 (dVdT)
unnamed: C52.1, EF2.18 (dVdT)
unnamed: C60.1, D2.1 (K), Q2.4 (BIAS)
unnamed: C61.1, D3.1 (K), Q3.4 (BIAS)
unnamed: C64.2, R77.2, R79.2
unnamed: C65.2, R78.2, R80.2
unnamed: C66.1, Q2.6 (CT)
unnamed: C67.1, Q3.6 (CT)
unnamed: EF1.3 (PGTH), R63.2, R64.1
unnamed: EF1.14 (EN/UVLO), R50.2, R51.1
unnamed: EF1.15 (OVP), R51.2, R52.1
unnamed: EF1.17 (ILIM), R59.2
unnamed: EF2.3 (PGTH), R65.2, R66.1
unnamed: EF2.14 (EN/UVLO), R54.2, R55.1
unnamed: EF2.15 (OVP), R55.2, R56.1
unnamed: EF2.17 (ILIM), R60.2
unnamed: ESD1.1 (A), ESD1.14 (A), JC1.2, R41.1
unnamed: ESD1.5 (VCC), JC1.1, R58.2
unnamed: ESD1.6 (E), ESD1.9 (E), JC1.7, R45.1
unnamed: ESD1.7 (F), ESD1.8 (F), JC1.8, R46.1
unnamed: ESD1.4 (D), ESD1.11 (D), JC1.5, R44.1
unnamed: ESD1.3 (C), ESD1.12 (C), JC1.4, R43.1
unnamed: ESD1.2 (B), ESD1.13 (B), JC1.3, R42.1
unnamed: F1.1, UA5.2
unnamed: F2.1, UA5.3
unnamed: FB1.1, L1.2
unnamed: FB2.1, R58.1
unnamed: LG1.4 (Y), Q2.3 (EN), Q3.3 (EN), R76.1
unnamed: R5.1, U1.138 (PH3)
unnamed: R6.1, U1.124 (PG9)
unnamed: R7.1, U1.22 (PF10)
unnamed: R8.1, U1.63 (PE10)
unnamed: R9.1, U1.65 (PE12)
unnamed: R12.2, U1.41 (PA5)
unnamed: R13.2, U1.74 (PB13)
unnamed: R57.2, Y2.1 (OE)
unnamed: R69.1, U2.4 (RXD)
unnamed: R70.1, U2.1 (TXD)
unnamed: R71.1, U3.4 (RXD)
unnamed: R72.1, U3.1 (TXD)
unnamed: R73.1, U2.8 (STBY)
unnamed: R74.1, U3.8 (STBY)
SPI_1_CS1: AS10.3 (NO3), H1.9
SPI_1_CS2: AS1.15 (NO2), H1.7
SPI_1_MISO: AS10.11 (NO1), H1.12
SPI_1_MOSI: AS10.7 (NO4), H1.10
SPI_1_SCK: AS10.15 (NO2), H1.11
SPI_2_CS1: AS11.3 (NO3), H2.9
SPI_2_CS2: AS2.15 (NO2), H2.7
SPI_2_MISO: AS11.11 (NO1), H2.12
SPI_2_MOSI: AS11.7 (NO4), H2.10
SPI_2_SCK: AS11.15 (NO2), H2.11
SUP_3V3: EF1.9 (IN), EF1.10 (IN), EF1.11 (IN), EF1.12 (IN), EF1.13 (IN), F1.2, H2.27, H2.28, R50.1
SUP_5V: EF2.9 (IN), EF2.10 (IN), EF2.11 (IN), EF2.12 (IN), EF2.13 (IN), F2.2, H2.25, H2.26, R54.1
UART_1_CTS: AS14.7 (NO4), H1.14
UART_1_RST: AS14.11 (NO1), H1.16
UART_1_RX: AS14.15 (NO2), H1.15
UART_1_TX: AS14.3 (NO3), H1.13
UART_2_CTS: AS15.7 (NO4), H2.14
UART_2_RST: AS15.11 (NO1), H2.16
UART_2_RX: AS15.15 (NO2), H2.15
UART_2_TX: AS15.3 (NO3), H2.13
UART_RCS_1_CTS: AS12.7 (NO4), H1.18
UART_RCS_1_RST: AS12.11 (NO1), H1.20
UART_RCS_1_RX: AS12.15 (NO2), H1.19
UART_RCS_1_TX: AS12.3 (NO3), H1.17
UART_RCS_2_CTS: AS13.7 (NO4), H2.18
UART_RCS_2_RST: AS13.11 (NO1), H2.20
UART_RCS_2_RX: AS13.3 (NO3), H2.19
UART_RCS_2_TX: AS13.15 (NO2), H2.17
USER_1_1: AS1.3 (NO3), H1.5
USER_1_2: AS1.7 (NO4), H1.6
USER_1_4: AS1.11 (NO1), H1.8
USER_2_1: AS2.3 (NO3), H2.5
USER_2_2: AS2.7 (NO4), H2.6
USER_2_4: AS2.11 (NO1), H2.8
USER_3_1: AS3.15 (NO2), H1.39
USER_3_2: AS3.3 (NO3), H1.40
USER_3_3: AS3.11 (NO1), H1.41
USER_3_4: AS3.7 (NO4), H1.42
USER_4_1: AS4.3 (NO3), H2.39
USER_4_2: AS4.11 (NO1), H2.40
USER_4_3: AS4.7 (NO4), H2.41
USER_4_4: AS4.15 (NO2), H2.42
USER_5_1: AS5.15 (NO2), H1.43
USER_5_2: AS5.7 (NO4), H1.44
USER_5_3: AS5.3 (NO3), H1.45
USER_5_4: AS5.11 (NO1), H1.46
USER_6_1: AS6.15 (NO2), H2.43
USER_6_2: AS6.3 (NO3), H2.44
USER_6_3: AS6.11 (NO1), H2.47
USER_6_4: AS6.7 (NO4), H2.48

Notes on the sheet:
RCS UART isolators
UART isolators
LSE and HSE clock sources
SW & UART peripheral with ESD protection
Power UV, OV, current protection and KillSwitch
Triple redundant F-RAM memory
Triple redundant FLASH memory
I2C 1 & 2 pull-up
LibreCube main headers
CAN FD transceiver
GLOBAL & CPU isolators
CAN & I2C isolators
*RESERVED
Temperature measurement
Universal SO-24
3V3
USER 5&6 isolators
USER 3&4 isolators - 3V3 tol.
USER 1&2 isolators
SPI isolators
reserved I2C1
Microcontroller

Board: 6 copper layers, 90.2 x 95.9 mm, 245 parts (116 on the bottom side), 232 nets.

Other parts of the board:
LOGO1: logo; VST_logo_horizontal_700
LOGO2: logo; LibreCube_logo_22.4mm
LOGO3: logo; OSH_logo_8mm

## Commit log

2020-11-19 Adds git submodule VST104 Libraries
2020-11-24 sync with library
2020-11-24 exports added
2020-11-24 pinout added
2020-11-25 pinout doc. update
2021-02-16 L1 to 0603
2021-02-17 BOM generation
2021-02-28 power management update
2021-02-28 cosmetic update
2021-02-28 BOM update
2021-03-01 libraries pulled
2021-03-01 gitignore updated
2021-03-01 libraries updated
2021-03-03 MCU resin hole added
2021-03-03 gerbers exported
2021-03-03 documents update
2021-03-03 library sync
2021-03-23 schem. cosmetic updates
